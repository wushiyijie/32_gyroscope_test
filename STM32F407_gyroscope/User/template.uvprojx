# Keil uVision project template.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\User;..\Startup;..\FWLib\inc;..\CMSIS;..\System\Delay;..\Hardware\Led;..\System\Sys;..\System\usart;..\Hardware\flash;..\Hardware\TIM;..\Hardware\mpu6050;..\Hardware\mpu6050\eMPL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h core_sc000.h core_sc300.h RTE_Components.h RTE_Device.h stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.c system_stm32f4xx.h
  group Startup
    ../Startup/: startup_stm32f40_41xxx.s
  group FWLib
    ../FWLib/src/: stm32f4xx_dac.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c misc.c stm32f4xx_flash.c
  group System
    ../System/Delay/: delay.c
    ../System/Sys/: sys.h
    ../System/usart/: usart.c
  group Hardware
    ../Hardware/Led/: led.c
    ../Hardware/flash/: flash.c
    ../Hardware/TIM/: tim.c
    ./: iic.c
    ../Hardware/mpu6050/: mpu6050.c
    ../Hardware/mpu6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group User
    ./: main.c
